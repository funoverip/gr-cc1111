<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>grc_cc1111_hackrf_sender</value></param>
<param><key>title</key><value>grc_cc1111_hackrf_sender</value></param>
<param><key>author</key><value>Jerome Nokin</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>433.6e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbole_rate</value></param>
<param><key>value</key><value>40000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_per_sym</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>'0101010101010101'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>int(samp_rate / symbole_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>'11010011100100011101001110010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>myqueue_in</value></param>
<param><key>value</key><value>gr.msg_queue(2)</value></param>
</block>
<block>
<key>cc1111_cc1111_packet_encoder</key>
<param><key>id</key><value>cc1111_cc1111_packet_encoder_0</value></param>
<param><key>source_queue</key><value>myqueue_in</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>bits_per_symbol</key><value>bit_per_sym</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>do_whitening</key><value>True</value></param>
<param><key>add_crc</key><value>True</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>hackrf</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>frequency</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>int(samp_per_sym)</value></param>
<param><key>bt</key><value>0.5</value></param>
</block>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_cc1111_packet_encoder_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
