<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>grc_cc1111_test_local_loop</value></param>
<param><key>title</key><value>grc_cc1111_test_local_loop</value></param>
<param><key>author</key><value>Jerome Nokin</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>'11010011100100011101001110010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>'0101010101010101'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbole_rate</value></param>
<param><key>value</key><value>80000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>int(samp_rate / symbole_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bit_per_sym</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>myqueue_out</value></param>
<param><key>value</key><value>gr.msg_queue(2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>myqueue_in</value></param>
<param><key>value</key><value>gr.msg_queue(2)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>samp_per_sym*(1+0.0)</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_bb</key>
<param><key>id</key><value>digital_correlate_access_code_bb_0_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>cc1111_cc1111_packet_decoder</key>
<param><key>id</key><value>cc1111_cc1111_packet_decoder_0</value></param>
<param><key>target_queue</key><value>myqueue_out</value></param>
<param><key>do_unwhitening</key><value>True</value></param>
<param><key>do_crc16_check</key><value>True</value></param>
<param><key>drop_header</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>cc1111_cc1111_packet_encoder</key>
<param><key>id</key><value>cc1111_cc1111_packet_encoder_0</value></param>
<param><key>source_queue</key><value>myqueue_in</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>bits_per_symbol</key><value>bit_per_sym</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>do_whitening</key><value>True</value></param>
<param><key>add_crc</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>int(samp_per_sym)</value></param>
<param><key>bt</key><value>0.5</value></param>
</block>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0_0</source_block_id><sink_block_id>digital_correlate_access_code_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_bb_0_0</source_block_id><sink_block_id>cc1111_cc1111_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_cc1111_packet_decoder_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc1111_cc1111_packet_encoder_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
